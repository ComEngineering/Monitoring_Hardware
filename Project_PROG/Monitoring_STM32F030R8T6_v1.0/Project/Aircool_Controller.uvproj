# Keil uVision project Aircool_Controller.uvproj, settings and files
target Aircool_Controller (ARM-ADS)
  device: STM32F030R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Monitoring +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F0xx,
  c misc: --C99
  c include: ..\CMSIS;..\StdLib\inc;..\Source
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../CMSIS/: startup_stm32f030.s system_stm32f0xx.c
  group StdLib
    ../StdLib/src/: stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group Source
    ../Source/: main.c one_wire_ds18b20.c stm32f0xx_it.c main_ini.c delay.c ModBus_slave.c Conditioner_operation.c
